Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-11-05T14:57:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20171027_0315(x64) - Exporter 17.0.1150.0 - Alternate UI 17.19.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Mon Nov 05 14:57:05 2018* Host: NCL-TA29* Database: C:\Users\Vickersc\AppData\Local\Temp\{ABE648A6-4B47-4390-BD1F-1349FAC130C8}\ifc* Database version: 5507* Database creation date: Mon Nov 05 14:57:05 2018* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Mon Nov 05 14:57:05 2018* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Mon Nov 05 14:57:05 2018* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcEnergyConversionDevice: WD05MotorBucket, NBS_Dyson_WtrSplyFitngsForWshBsnsAndTrghs_DysonAirbladeWashAndDry_WD05MotorBucket:WD05MotorBucket:312702
In: Level 0
Type - PredefinedType: USERDEFINED; Material: NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_WaterSupplyFittingsForWashBasinsAndTroughs_Dyson_DysonAirbladeWashAndDry_WD05MotorBucket; ManufacturerName: Dyson; ManufacturerURL: www.dysonairblade.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/0dagsdgg; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: www.dysonairblade.co.uk/medialibrary/Files/Tech%20Specs/TapTECHSPECGBI.pdf; Revision: n/a; Uniclass2015Code: Pr_40_20_87_98; Uniclass2015Title: Washbasin taps; Uniclass2015Version: Products v1.11; Version: 5
Type - NBS_Data - EquipmentElectricalPower: Mains; MinimumClearance: 100 mm clearance from floor; MotorRotationFrequency: 90000 rpm; MotorSwitchingRate: 6000/s; MotorType: Dyson digital motor - brushless DC Motor; StandbyPowerConsumption: <0.5 W
Type - Pset_ElectricMotorTypeCommon - Reference: n/a; MaximumPowerOutput: 0; ElectricMotorEfficiency: 0; StartCurrentFactor: 0; StartingTime: 0; TeTime: 0; LockedRotorCurrent: 0; FrameSize: n/a; IsGuarded: no; HasPartWinding: no
Type - Pset_ElectricalDeviceCommon - RatedCurrent: 0.0 , 0.0; RatedVoltage: 220.0 , 253.0; NominalFrequencyRange: 50.0 , 50.0; PowerFactor: 0; NumberOfPoles: 0; HasProtectiveEarth: no; IP_Code: IP35; IK_Code: n/a
Type - IFC - IfcExportAs: IfcElectricMotorType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_87_98:Washbasin taps; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Digital motor to be used in conjunction with WD05 Dyson Airblade Wash+Dry; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: specification@dysonairblade.co.uk; Material: n/a; ModelNumber: WD05; ModelReference: Dyson Airblade Wash+Dry; Name: Dyson_DysonAirbladeWashAndDry_WD05MotorBucket_WaterSupplyFittingsForWashBasinsAndTroughs; NominalHeight: 262 mm; NominalLength: 189 mm; NominalWidth: 141 mm; ReplacementCost: n/a; Shape: n/a; Size: 189 x 141 x 262 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 5; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: 5025155015773; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
