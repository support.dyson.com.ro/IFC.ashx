Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-11-05T14:53:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20171027_0315(x64) - Exporter 17.0.1150.0 - Alternate UI 17.19.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Mon Nov 05 14:53:18 2018* Host: NCL-TA29* Database: C:\Users\Vickersc\AppData\Local\Temp\{57FF4BAC-CD55-4184-AF31-A05D0980067D}\ifc* Database version: 5507* Database creation date: Mon Nov 05 14:53:17 2018* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Mon Nov 05 14:53:17 2018* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Mon Nov 05 14:53:17 2018* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowController: WD06, NBS_Dyson_WtrSplyFitngsForWshBsnsAndTrghs_DysonAirbladeWashAndDry_WD06:WD06:311661
In: Level 0
Type - PredefinedType: FAUCET; Material: NBS_Concept
Type - NBS_General - Author: NBS; BIMObjectName: NBS_WaterSupplyFittingsForWashBasinsAndTroughs_Dyson_DysonAirbladeWashAndDry-WD06; ManufacturerName: Dyson; ManufacturerURL: www.dysonairblade.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/mheipl0a; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: www.dysonairblade.co.uk/medialibrary/Files/Tech%20Specs/TapTECHSPECGBI.pdf; Revision: n/a; Uniclass2015Code: Pr_40_20_87_98; Uniclass2015Title: Washbasin taps; Uniclass2015Version: Products v1.11; Version: 7
Type - NBS_Data - Certification: NSF approved; IntegralAccessories: Dyson digital motor; MaximumWaterSupplyTemperature: n/a; ApertureAirspeed: 430 mph; BacteriaReductionRate: 0.999; HandDryerForm: High velocity cold air through HEPA filter; HandDryingTime: 12 s; OperatingAirflow: 30 L/s; OperatingTemperature: 0-40°C; AutomaticShutOffTime: 30 s; WaterFeed: 1/2" BSP; WaterTemperatureControl: Thermostatic mixer recommended (not supplied)
Type - Pset_ValveTypeFaucet - FaucetType: PILLAR; FaucetOperation: TIMEDSELFCLOSING; FaucetFunction: MIXED; Finish: Brushed; FaucetTopDescription: n/a
Type - Pset_ValveTypeCommon - Reference: n/a; ValvePattern: SINGLEPORT; Size: 25.4; TestPressure: 8; WorkingPressure: 0; FlowCoefficient: 0; CloseOffRating: 0
Type - IFC - IfcExportAs: IfcValveType; IfcExportType: FAUCET
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Plumbing Fixtures; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: Wash and dry hand dryer; DurationUnit: year; ExpectedLife: n/a; Features: Aerated water outlet, hygienic, quick drying; Finish: Brushed; Grade: n/a; Manufacturer: specification@dysonairblade.co.uk; Material: Stainless steel; ModelNumber: WD06; ModelReference: Dyson Airblade Wash+Dry; Name: DysonAirbladeWashAndDry-WD06_WaterSupplyFittingsForWashBasinsAndTroughs; NominalHeight: 0 mm; NominalLength: 305 mm; NominalWidth: 295 mm; ReplacementCost: n/a; Shape: n/a; Size: 25.4; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: 5; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: 5025155015797; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
